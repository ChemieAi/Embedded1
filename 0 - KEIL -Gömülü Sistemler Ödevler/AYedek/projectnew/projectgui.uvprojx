# Keil uVision project projectgui.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: projectgui
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1, Graphics:CORE 6.32.3, Graphics:Display:MCBQVGA_LG 6.32.3, Graphics:Input Device:Joystick 6.32.3, Graphics:Input Device:Touchscreen 6.32.3
